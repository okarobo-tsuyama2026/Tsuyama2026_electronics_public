# Repository okarobo-tsuyama2026/Tsuyama2026_electronics_public (continued)

## KiCad design servo_control_board/servo_control_board.kicad_pcb (continued)

Board: 2 copper layers, 85.0 x 35.0 mm, 34 parts (0 on the bottom side), 15 nets.

## KiCad design Nucleo-F303K8_control_board/Nucleo-F303K8_control_board.kicad_pcb

File Nucleo-F303K8_control_board/README.md:

# 【ver 】Nucleo-F303K8_control_board

## 回路図 (Schematic)

---

## 外観 (3D Rendering)

| 表面 (Top) | 裏面 (Bottom) |
| :---: | :---: |
|  |  |

| 斜視 (Isometric) | 反対斜視 (Reverse Isometric) |
| :---: | :---: |
|  |  |

---

## 機能の紹介

---

## コネクタ・ピンアサイン

### J1: 

| ピン | 種類 | 信号名 | 説明 |
| --- | --- | --- | --- |
| | | | |

---

## 安全・禁止事項・注意事項

### 禁止事項

### 注意事項

---

## 更新履歴
| 対象基板バージョン | 日付 | 変更内容 |
| --- | --- | --- |
| | | |

---

## 関連成果物・リンク

- **回路図 (PDF)**: [`docs/Nucleo-F303K8_control_board_schematic.pdf`](docs/Nucleo-F303K8_control_board_schematic.pdf)
- **回路図 (SVG)**: [`docs/Nucleo-F303K8_control_board_schematic.svg`](docs/Nucleo-F303K8_control_board_schematic.svg)
- **部品表 (BOM)**: [`docs/Nucleo-F303K8_control_board_bom.csv`](docs/Nucleo-F303K8_control_board_bom.csv)
- **3D CADモデル (STEP)**: [`Nucleo-F303K8_control_board.step`](Nucleo-F303K8_control_board.step)
- **製造データ (Gerber)**: 発注用ガーバーZIPは [GitHub Releases](../../releases) を参照してください。

Parts:
C1: 47u; CP_Radial_D6.3mm_P2.50mm
C2, C5: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C3, C4: R兼用; C_Disc_D3.8mm_W2.6mm_P2.50mm; not fitted
D1: LED; LED_D5.0mm
J1, J5: Conn_01x02_Pin; DF1E-2P-2.5DS
J2, J3: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical; not fitted
J4: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J6, J10, J11: Conn_01x04_Pin; DF1E-4P-2.5DS
J7, J8, J9: Conn_01x03_Pin; S03B-PASK-2
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2, R3: R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
R4, R5: 0; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
R6: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R7, R8: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
U1: NUCLEO-F303K8; PARTREV 5
U2: MCP2562-E-P; DIP-8_W7.62mm

Connections:
+3.3V: C5.2, J2.2, J3.2, J6.3, J10.3, R2.2, R3.2, R7.1, R8.1, U1.4_14 (+3V3), U2.5 (Vio)
+5V: C1.1, C2.1, J1.2, J11.3, R1.1, U1.4_4 (+5V), U2.3 (VDD)
/CAN1+: J4.2, J5.1, U2.7 (CANH)
/CAN1-: J5.2, R6.2, U2.6 (CANL)
/CAN1_RX: U1.3_13 (PA11), U2.4 (RXD)
/CAN1_TX: U1.3_5 (PA12), U2.1 (TXD)
/I2C_SCL: J6.2, R8.2, U1.3_8 (PB6)
/I2C_SDA: J6.4, R7.2, U1.3_7 (PB7)
/PA3: R4.1, U1.4_10 (PA3)
/PA4: R5.1, U1.4_9 (PA4)
/PA5: J10.2, U1.4_8 (PA5)
/PA6: J10.4, U1.4_7 (PA6)
/PA9: J11.2, U1.3_1 (PA9)
/PA10: J11.4, U1.3_2 (PA10)
/PWM1: J7.3, U1.3_15 (PB4)
/PWM2: J7.1, U1.3_14 (PB5)
/PWM3: J8.3, U1.3_6 (PB0)
/PWM4: J8.1, U1.3_9 (PB1)
/PWM5: J9.3, U1.4_12 (PA0)
/PWM6: J9.1, U1.4_11 (PA1)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, D1.1 (K), J1.1, J2.3, J3.3, J6.1, J7.2, J8.2, J9.2, J10.1, J11.1, U1.3_4 (GND_1), U1.4_2 (GND_2), U2.2 (VSS), U2.8 (STBY)
unnamed: D1.2 (A), R1.2
unnamed: C3.1, J2.1, R2.1, R4.2
unnamed: C4.1, J3.1, R3.1, R5.2
unnamed: J4.1, R6.1

Notes on the sheet:
シリアルサーボ
5V電源LED
プルアップ プルダウン RCフィルタ に対応
PWM
CAN通信
I2C
予備GPIO
空圧用

Board: 2 copper layers, 55.0 x 70.0 mm, 27 parts (0 on the bottom side), 25 nets.

File Nucleo-F303K8_control_board/docs/Nucleo-F303K8_control_board_bom.csv:

"Reference","Qty","Value","Footprint","説明","Buy_URL"
"C1","1","47u","Capacitor_THT:CP_Radial_D6.3mm_P2.50mm","47μF63V","https://akizukidenshi.com/catalog/g/g117403/"
"C2,C5","2","0.1u","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P2.50mm","0.1μF50V X7R","https://akizukidenshi.com/catalog/g/g113582/"
"C3,C4","2","R兼用","Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm","Unpolarized capacitor",""
"D1","1","LED","LED_THT:LED_D5.0mm","Light emitting diode",""
"J1,J5","2","Conn_01x02_Pin","OU_connector:DF1E-2P-2.5DS","DF1E-2P-2.5DS",""
"J2,J3","2","Conn_01x03_Pin","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","Generic connector, single row, 01x03, script generated",""
"J4","1","Conn_01x02_Pin","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","Generic connector, single row, 01x02, script generated",""
"J6,J10,J11","3","Conn_01x04_Pin","OU_connector:DF1E-4P-2.5DS","DF1E-4P-2.5DS",""
"J7-J9","3","Conn_01x03_Pin","OU_connector:S03B-PASK-2","S03B-PASK-2",""
"R1","1","1k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","Resistor",""
"R2,R3","2","","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","Resistor",""
"R4,R5","2","0","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","Resistor",""
"R6","1","120","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","Resistor","https://akizukidenshi.com/catalog/g/g125121/"
"R7,R8","2","4.7k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","Resistor","https://akizukidenshi.com/catalog/g/g125472/"
"U1","1","NUCLEO-F303K8","OU_Micon:NUCLEO-F303K8","STM32F303K8, mbed-Enabled Development Nucleo-32 STM32F3 ARM® Cortex®-M4 MCU 32-Bit Embedded Evaluation Board",""
"U2","1","MCP2562-E-P","Package_DIP:DIP-8_W7.62mm","High-Speed CAN Transceiver, 1Mbps, 5V supply, Vio pin, -40C to +125C, DIP-8","https://akizukidenshi.com/catalog/g/g114383/"

## KiCad design servo_power_board/servo_power_board.kicad_pcb

Parts:
C1: 330u; CP_Radial_D10.0mm_P5.00mm_H23mm_Horizontal1
C2, C4: 100u; CP_Radial_D10.0mm_P5.00mm
C3: 2.2u; C_Disc_D6.0mm_W4.4mm_P5.00mm
C5: 470u; CP_Radial_D10.0mm_P5.00mm
D1: LED; LED_D5.0mm
J1: Conn_01x02_Pin; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2, J4, J5, J6: Conn_01x02_Socket; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J3: Conn_01x02_Pin; DF1EC-2P-2.5DSA
R1: 7.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2: 12k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3: 1.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
RV1: 20k; TRIM_3006P
TP1: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP2: TestPoint_Probe; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: YDS512F

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.1 (K), J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, R3.2, TP1.1 (1_1), U1.3 (GND), U1.4 (GND)
unnamed: D1.2 (A), R1.2
unnamed: C1.1, C2.1, C3.1, J1.2, J2.2, R1.1, U1.1 (Vin), U1.2 (Vin)
unnamed: C4.1, C5.1, J3.2, J4.2, J5.2, J6.2, R2.1, TP2.1 (1_1), U1.5 (VOUT), U1.6 (VOUT)
unnamed: R2.2, RV1.3
unnamed: R3.1, RV1.1
unnamed: RV1.2, U1.7 (Vadj)

Notes on the sheet:
電源LED
電圧モニタ用

Board: 2 copper layers, 85.0 x 55.0 mm, 19 parts (1 on the bottom side), 7 nets.

## KiCad design DCmotor_control_board/DCmotor_control_board.kicad_pcb

File DCmotor_control_board/README.md:

# 【ver 1.1】DCmotor_control_board
この基板は以下のような機能を持っています．
- 2つのDCモータの正転・逆転・ブレーキをPWM制御
- フォトカプラにより制御系と駆動系を絶縁

## 回路図 (Schematic)

---

## 外観 (3D Rendering)

|        表面 (Top)         |          裏面 (Bottom)          |
| :---------------------: | :---------------------------: |
|  |  |

| 斜視 (Isometric) | 反対斜視 (Reverse Isometric) |
| :---: | :---: |
|  |  |

---

## 機能の紹介
### PWMモータ制御
IN1〜4にはPWM信号を入力することができ，デューティー比を変更することにより，加減速を行うことができる．
なお，PWM周波数は20kHz〜100kHzの範囲で運用することを推奨し，1kHz以下や400kHz以上で運用することはできない．これは主にモータドライバの限界と人の可聴域に起因する．
### 絶縁
GND1，GND2，GNDPWRはそれぞれ絶縁されている．そのため，もし，同一マイコンでCH1とCH2の両方を制御したい場合であっても，GND1とGND2の両方をマイコンのGNDと接続しなければならない．
### インジケータLED
#### D1: モータ電源LED
| LED | 状態                    |
| --- | --------------------- |
| 点灯  | 電源入力端子(J1)に電源が接続されている |
| 消灯  | 電源が接続されていない           |

このLEDはモータ電源に接続されているのではなく，L7805によって作られる5Vによって駆動されていることに注意しなければならない．例えばL7805が壊れた場合，モータ電源を接続してもLEDが光らないことがある．

---

## コネクタ・ピンアサイン

### J1: 電源入力
電源入力用のコネクタ．

| ピン  | 種類   | 信号名    | 説明                       |
| --- | ---- | ------ | ------------------------ |
| 1   | 電源入力 | GNDPWR |                          |
| 2   | 電源入力 | +MOTOR | 8~24Vを推奨．35V以下でなければいけない． |

### J2: 信号入力(CH1)
CH1モータ用の信号入力端子．

| ピン  | 種類   | 信号名  | 説明                   |
| --- | ---- | ---- | -------------------- |
| 1   | 電源   | GND1 |                      |
| 2   | 信号入力 | IN1  | 3.3Vロジック．順電流は約3.7mA． |
| 3   | 未接続  | NC   |                      |
| 4   | 信号入力 | IN2  | 3.3Vロジック．順電流は約3.7mA． |

| IN1 | IN2 | モータ(CH1)の動作 |
| --- | --- | ----------- |
| L   | L   | ストップ        |
| H   | L   | 正転          |
| L   | H   | 逆転          |
| H   | H   | ブレーキ        |

### J3: 信号入力(CH2)
CH2モータ用の信号入力端子．

| ピン  | 種類   | 信号名  | 説明                   |
| --- | ---- | ---- | -------------------- |
| 1   | 電源   | GND2 |                      |
| 2   | 信号入力 | IN3  | 3.3Vロジック．順電流は約3.7mA． |
| 3   | 未接続  | NC   |                      |
| 4   | 信号入力 | IN4  | 3.3Vロジック．順電流は約3.7mA． |

| IN3 | IN4 | モータ(CH2)の動作 |
| --- | --- | ----------- |
| L   | L   | ストップ        |
| H   | L   | 正転          |
| L   | H   | 逆転          |
| H   | H   | ブレーキ        |

### J4: モータ(CH1)
CH1のモータを接続する端子．モータドライバの発熱なども考慮し，出力電流は2.45A以下が推奨される．出力電流が3.5Aを超えてはならない．

| ピン  | 種類   | 信号名       | 説明         |
| --- | ---- | --------- | ---------- |
| 1   | 電源出力 | OUT1(CH1) | モータの+端子を接続 |
| 2   | 電源出力 | OUT2(CH1) | モータの-端子を接続 |

| IN1 | IN2 | OUT1 | OUT2 |
| --- | --- | ---- | ---- |
| L   | L   | Hi-Z | Hi-Z |
| H   | L   | H    | L    |
| L   | H   | L    | H    |
| H   | H   | L    | L    |

### J5: モータ(CH2)
CH2のモータを接続する端子．モータドライバの発熱なども考慮し，出力電流は2.45A以下が推奨される．出力電流が3.5Aを超えてはならない．

| ピン  | 種類   | 信号名       | 説明         |
| --- | ---- | --------- | ---------- |
| 1   | 電源出力 | OUT1(CH2) | モータの+端子を接続 |
| 2   | 電源出力 | OUT2(CH2) | モータの-端子を接続 |

| IN3 | IN4 | OUT1 | OUT2 |
| --- | --- | ---- | ---- |
| L   | L   | Hi-Z | Hi-Z |
| H   | L   | H    | L    |
| L   | H   | L    | H    |
| H   | H   | L    | L    |

---

## 安全・禁止事項・注意事項

### 禁止事項
#### 電源の逆接続
本基板には逆接続保護回路が無い．J1に対し，電源の+-を逆に接続すると基板上の複数の部品が破損・発火する可能性がある．

### 注意事項
#### 入力電圧が高い場合のレギュレータ(U1)の発熱
モータ電源の電圧が24Vなど高い場合，L7805CVの入出力電圧差によって発熱が大きくなる．連続稼働時はレギュレータの発熱が許容範囲内か確認することを推奨する．

---

## 更新履歴
| 対象基板バージョン | 日付    | 変更内容               |
| --------- | ----- | ------------------ |
| 1.1       | 10/12 | ドキュメントを作成          |
| 1.1       | 10/12 | GitHubで表示が崩れる問題を修正 |
| 1.1       | 10/12 | GitHubで表示が崩れる問題を修正 |

---

## 関連成果物・リンク

- **回路図 (PDF)**: [`docs/DCmotor_control_board_schematic.pdf`](docs/DCmotor_control_board_schematic.pdf)
- **回路図 (SVG)**: [`docs/DCmotor_control_board_schematic.svg`](docs/DCmotor_control_board_schematic.svg)
- **部品表 (BOM)**: [`docs/DCmotor_control_board_bom.csv`](docs/DCmotor_control_board_bom.csv)
- **3D CADモデル (STEP)**: [`DCmotor_control_board.step`](DCmotor_control_board.step)
- **製造データ (Gerber)**: 発注用ガーバーZIPは [GitHub Releases](../../releases) を参照してください。

Parts:
C1: 0.33u; C_Disc_D3.8mm_W2.6mm_P2.50mm
C2: 330u; CP_Radial_D10.0mm_P5.00mm
C3, C4, C5, C6, C7, C8: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
D1: LED; LED_D5.0mm
J1: Conn_01x02_Pin; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2, J3: Conn_01x04_Pin; DF1E-4P-2.5DS
J4, J5: Conn_01x02_Pin; DF1E-2P-2.5DS
R1, R2, R4, R5: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
U1: L7805CV; TO-220-3_Vertical
U2, U3, U5, U6: TLP2745; SO-6L_10x3.84mm_P1.27mm
U4, U7: TB67H450FNG_EL; P-HSOP8-0405-1p27-002_TOS-L

Connections:
+5V: C4.2, C5.2, C6.2, C7.2, C8.2, R3.1, U1.3 (OUT), U2.6 (VDD), U3.6 (VDD), U4.4 (VREF), U5.6 (VDD), U6.6 (VDD), U7.4 (VREF)
+MOTOR: C1.2, C2.1, C3.2, J1.2, U1.1 (IN), U4.5 (VM), U7.5 (VM)
/IN1_1: U2.5 (VO), U4.3 (IN1)
/IN1_2: U3.5 (VO), U4.2 (IN2)
/IN2_1: U5.5 (VO), U7.3 (IN1)
/IN2_2: U6.5 (VO), U7.2 (IN2)
/SIG_IN1: J2.2, R1.1
/SIG_IN2: J2.4, R2.1
/SIG_IN3: J3.2, R4.1
/SIG_IN4: J3.4, R5.1
GND1: J2.1, U2.3 (K), U3.3 (K)
GND2: J3.1, U5.3 (K), U6.3 (K)
GNDPWR: C1.1, C2.2, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, D1.1 (K), J1.1, U1.2, U2.4 (GND), U3.4 (GND), U4.1 (GND), U4.7 (RS), U4.9 (GND), U5.4 (GND), U6.4 (GND), U7.1 (GND), U7.7 (RS), U7.9 (GND)
unnamed: D1.2 (A), R3.2
unnamed: J4.1, U4.6 (OUT1)
unnamed: J4.2, U4.8 (OUT2)
unnamed: J5.1, U7.6 (OUT1)
unnamed: J5.2, U7.8 (OUT2)
unnamed: R1.2, U2.1 (A)
unnamed: R2.2, U3.1 (A)
unnamed: R4.2, U5.1 (A)
unnamed: R5.2, U6.1 (A)

Notes on the sheet:
モータドライバ CH2
モータ電源LED
モータドライバ CH1

Board: 2 copper layers, 45.0 x 55.0 mm, 26 parts (2 on the bottom side), 22 nets.
