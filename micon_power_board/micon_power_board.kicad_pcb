# Repository okarobo-tsuyama2026/Tsuyama2026_electronics_public

File README.md:

# Tsuyama2026_electronics (Public)

本リポジトリは、ロボット開発における各回路基板の回路図、3Dモデル、ピンアサイン等の公開用リソースを管理しています。

## 収録基板一覧

| 基板名 | 概要 | 回路図 | 3Dモデル | 部品表 (BOM) |
| :--- | :--- | :---: | :---: | :---: |
| [24v_power_board](24v_power_board/) | | [PDF](24v_power_board/docs/24v_power_board_schematic.pdf) / [SVG](24v_power_board/docs/24v_power_board_schematic.svg) | [STEP](24v_power_board/24v_power_board.step) | [CSV](24v_power_board/docs/24v_power_board_bom.csv) |
| [DCmotor_control_board](DCmotor_control_board/) | | [PDF](DCmotor_control_board/docs/DCmotor_control_board_schematic.pdf) / [SVG](DCmotor_control_board/docs/DCmotor_control_board_schematic.svg) | [STEP](DCmotor_control_board/DCmotor_control_board.step) | [CSV](DCmotor_control_board/docs/DCmotor_control_board_bom.csv) |
| [ESP32-DevKitC_control_board](ESP32-DevKitC_control_board/) | | [PDF](ESP32-DevKitC_control_board/docs/ESP32-DevKitC_control_board_schematic.pdf) / [SVG](ESP32-DevKitC_control_board/docs/ESP32-DevKitC_control_board_schematic.svg) | [STEP](ESP32-DevKitC_control_board/ESP32-DevKitC_control_board.step) | [CSV](ESP32-DevKitC_control_board/docs/ESP32-DevKitC_control_board_bom.csv) |
| [Nucleo-F303K8_control_board](Nucleo-F303K8_control_board/) | | [PDF](Nucleo-F303K8_control_board/docs/Nucleo-F303K8_control_board_schematic.pdf) / [SVG](Nucleo-F303K8_control_board/docs/Nucleo-F303K8_control_board_schematic.svg) | [STEP](Nucleo-F303K8_control_board/Nucleo-F303K8_control_board.step) | [CSV](Nucleo-F303K8_control_board/docs/Nucleo-F303K8_control_board_bom.csv) |
| [Nucleo-F446RE_control_board](Nucleo-F446RE_control_board/) | | [PDF](Nucleo-F446RE_control_board/docs/Nucleo-F446RE_control_board_schematic.pdf) / [SVG](Nucleo-F446RE_control_board/docs/Nucleo-F446RE_control_board_schematic.svg) | [STEP](Nucleo-F446RE_control_board/Nucleo-F446RE_control_board.step) | [CSV](Nucleo-F446RE_control_board/docs/Nucleo-F446RE_control_board_bom.csv) |
| [micon_power_board](micon_power_board/) | | [PDF](micon_power_board/docs/micon_power_board_schematic.pdf) / [SVG](micon_power_board/docs/micon_power_board_schematic.svg) | [STEP](micon_power_board/micon_power_board.step) | [CSV](micon_power_board/docs/micon_power_board_bom.csv) |
| [serial_servo_control_board](serial_servo_control_board/) | | [PDF](serial_servo_control_board/docs/serial_servo_control_board_schematic.pdf) / [SVG](serial_servo_control_board/docs/serial_servo_control_board_schematic.svg) | [STEP](serial_servo_control_board/serial_servo_control_board.step) | [CSV](serial_servo_control_board/docs/serial_servo_control_board_bom.csv) |
| [servo_control_board](servo_control_board/) | | [PDF](servo_control_board/docs/servo_control_board_schematic.pdf) / [SVG](servo_control_board/docs/servo_control_board_schematic.svg) | [STEP](servo_control_board/servo_control_board.step) | [CSV](servo_control_board/docs/servo_control_board_bom.csv) |
| [servo_power_board](servo_power_board/) | | [PDF](servo_power_board/docs/servo_power_board_schematic.pdf) / [SVG](servo_power_board/docs/servo_power_board_schematic.svg) | [STEP](servo_power_board/servo_power_board.step) | [CSV](servo_power_board/docs/servo_power_board_bom.csv) |

---

## ライセンス・注意事項
- 製造用ガーバーファイル（Gerber）は、各バージョンの [Releases](../../releases) よりダウンロードしてください。

## KiCad design micon_power_board/micon_power_board.kicad_pcb

File micon_power_board/README.md:

# 【ver 】micon_power_board

## 回路図 (Schematic)

---

## 外観 (3D Rendering)

| 表面 (Top) | 裏面 (Bottom) |
| :---: | :---: |
|  |  |

| 斜視 (Isometric) | 反対斜視 (Reverse Isometric) |
| :---: | :---: |
|  |  |

---

## 機能の紹介

---

## コネクタ・ピンアサイン

### J1: 

| ピン | 種類 | 信号名 | 説明 |
| --- | --- | --- | --- |
| | | | |

---

## 安全・禁止事項・注意事項

### 禁止事項

### 注意事項

---

## 更新履歴
| 対象基板バージョン | 日付 | 変更内容 |
| --- | --- | --- |
| | | |

---

## 関連成果物・リンク

- **回路図 (PDF)**: [`docs/micon_power_board_schematic.pdf`](docs/micon_power_board_schematic.pdf)
- **回路図 (SVG)**: [`docs/micon_power_board_schematic.svg`](docs/micon_power_board_schematic.svg)
- **部品表 (BOM)**: [`docs/micon_power_board_bom.csv`](docs/micon_power_board_bom.csv)
- **3D CADモデル (STEP)**: [`micon_power_board.step`](micon_power_board.step)
- **製造データ (Gerber)**: 発注用ガーバーZIPは [GitHub Releases](../../releases) を参照してください。

Parts:
C1: 100u; CP_Radial_D8.0mm_P3.50mm
C2: 10u; C_Disc_D6.0mm_W4.4mm_P5.00mm
C3: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C4, C5: 2.2u; C_Disc_D6.0mm_W4.4mm_P5.00mm
D1: SBM1060LSS; D_DO-201AD_P3.81mm_Vertical_CathodeUp
D2, D3: LED; LED_D5.0mm
J1, J2, J3, J4, J5: Conn_01x02_Pin; DF1E-2P-2.5DS
J6: Conn_01x02_Pin; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J7: Conn_01x02_Socket; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
R1: 7.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
TP1, TP2: TestPoint_Probe; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP3: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: M78AR05-1

Connections:
GND: C1.2, C2.2, C3.1, C4.2, C5.2, D2.1 (K), D3.1 (K), J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, TP3.1 (1_1), U1.2 (GND)
unnamed: D1.2 (A), J6.2, J7.2
unnamed: C1.1, C2.1, C3.2, D1.1 (K), R1.1, TP1.1 (1_1), U1.1 (VI)
unnamed: D2.2 (A), R1.2
unnamed: D3.2 (A), R2.2
unnamed: C4.1, C5.1, J1.2, J2.2, J3.2, J4.2, J5.2, R2.1, TP2.1 (1_1), U1.3 (VO)

Notes on the sheet:
2.2uFが余っているため 4.7uF一つでも良い
電源LED
5V電源LED

Board: 2 copper layers, 55.0 x 45.0 mm, 21 parts (0 on the bottom side), 6 nets.

## KiCad design ESP32-DevKitC_control_board/ESP32-DevKitC_control_board.kicad_pcb

File ESP32-DevKitC_control_board/README.md:

# 【ver 1.1】ESP32-DevKitC_control_board

## 回路図 (Schematic)

---

## 外観 (3D Rendering)

|        表面 (Top)         |          裏面 (Bottom)          |
| :---------------------: | :---------------------------: |
|  |  |

| 斜視 (Isometric) | 反対斜視 (Reverse Isometric) |
| :---: | :---: |
|  |  |

---

## 機能の紹介
### ペリフェラル
#### PWM
PWMはJ1に2ch，J2に2chの合計4ch引き出されている．

| マイコン側  | 信号名  |
| ------ | ---- |
| GPIO14 | PWM1 |
| GPIO27 | PWM2 |
| GPIO25 | PWM3 |
| GPIO26 | PWM4 |
#### I2C
I2CはJ6に1ch引き出されている．

| マイコン側  | 信号名     |
| ------ | ------- |
| GPIO21 | I2C_SDA |
| GPIO22 | I2C_SCL |

なお，R3とR4を実装することにより，SDAとSCLを3.3Vでプルアップすることができる．
#### CAN
CANはJ5に1ch引き出されている．

| マイコン側  | 信号名    |
| ------ | ------ |
| GPIO18 | CAN_RX |
| GPIO19 | CAN_TX |
#### シリアル
シリアルサーボへ接続することを想定し，J7に1GPIOのみ1ch引き出されている．なお，プルアップはされていない．

| マイコン側 | 信号名   |
| ----- | ----- |
| 3.3V  | 3.3V  |
| GPIO4 | GPIO4 |
#### 予備GPIO
汎用用途にGPIO13，GPIO23，GPIO32，GPIO33が引き出されている．
各GPIOには以下のような回路が接続されており，以下の例ではR5，R9，C4に部品を実装することで，信号線のプルアップ，プルダウン，RCフィルタなどの処理を施すことができる．

なお，基板上ではリファレンスに加えて以下のように記載されている．

| 上図での例 | 基板上での表示      |
| ----- | ------------ |
| R5    | P-up         |
| R9    | Lp-R         |
| C4    | Lp-C<br>P-dn |

施したい処理に応じた部品の実装の対応は以下のようになっている．
##### 通常時
| 対象           | 実装     |
| ------------ | ------ |
| P-up         | 未実装    |
| Lp-R         | 0Ω(短絡) |
| Lp-C<br>P-dn | 未実装    |
##### プルアップ
| 対象           | 実装      |
| ------------ | ------- |
| P-up         | プルアップ抵抗 |
| Lp-R         | 0Ω(短絡)  |
| Lp-C<br>P-dn | 未実装     |
##### プルダウン
| 対象           | 実装      |
| ------------ | ------- |
| P-up         | 未実装     |
| Lp-R         | 0Ω(短絡)  |
| Lp-C<br>P-dn | プルダウン抵抗 |
##### RCフィルタ(ローパスフィルタ)
| 対象           | 実装    |
| ------------ | ----- |
| P-up         | 未実装   |
| Lp-R         | 抵抗    |
| Lp-C<br>P-dn | コンデンサ |
### インジケータLED
#### D1: 電源LED
| LED | 状態                |
| --- | ----------------- |
| 点灯  | 電源入力端子に電源が接続されている |
| 消灯  | 電源が接続されていない       |

---

## コネクタ・ピンアサイン

### J1: 

| ピン  | 種類  | 信号名 | 説明  |
| --- | --- | --- | --- |
|     |     |     |     |

---

## 安全・禁止事項・注意事項

### 禁止事項

### 注意事項

---

## 更新履歴
| 対象基板バージョン | 日付  | 変更内容 |
| --------- | --- | ---- |
|           |     |      |

---

## 関連成果物・リンク

- **回路図 (PDF)**: [`docs/ESP32-DevKitC_control_board_schematic.pdf`](docs/ESP32-DevKitC_control_board_schematic.pdf)
- **回路図 (SVG)**: [`docs/ESP32-DevKitC_control_board_schematic.svg`](docs/ESP32-DevKitC_control_board_schematic.svg)
- **部品表 (BOM)**: [`docs/ESP32-DevKitC_control_board_bom.csv`](docs/ESP32-DevKitC_control_board_bom.csv)
- **3D CADモデル (STEP)**: [`ESP32-DevKitC_control_board.step`](ESP32-DevKitC_control_board.step)
- **製造データ (Gerber)**: 発注用ガーバーZIPは [GitHub Releases](../../releases) を参照してください。

Parts:
C1, C3: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C2: 47u; CP_Radial_D6.3mm_P2.50mm
C4, C5, C6, C7: R兼用; C_Disc_D3.8mm_W2.6mm_P2.50mm; not fitted
D1: LED; LED_D5.0mm
J1, J2: Conn_01x03_Pin; S03B-PASK-2
J3, J5, J7: Conn_01x02_Pin; DF1E-2P-2.5DS
J4: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J6: Conn_01x04_Pin; DF1E-4P-2.5DS
J8, J9, J10, J11: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical; not fitted
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3, R4: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
R5, R6, R7, R8: R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
R9, R10, R11, R12: 0; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
U1: MCP2562-E-P; DIP-8_W7.62mm
U2: ESP32-DevKitC

Connections:
+3.3V: C3.2, J6.3, J7.1, J8.2, J9.2, J10.2, J11.2, R3.1, R4.1, R5.2, R6.2, R7.2, R8.2, U1.5 (Vio), U2.1 (3V3)
+5V: C1.1, C2.1, J3.2, R1.1, U1.3 (VDD), U2.19 (5V)
/CAN1+: J4.2, J5.1, U1.7 (CANH)
/CAN1-: J5.2, R2.2, U1.6 (CANL)
/CAN_RX: U1.4 (RXD), U2.30 (GPIO18)
/CAN_TX: U1.1 (TXD), U2.31 (GPIO19)
/GPIO4: J7.2, U2.26 (ADC2_CH0/GPIO4)
/GPIO13: R9.1, U2.15 (MTCK/GPIO13/ADC2_CH4)
/GPIO23: R10.1, U2.37 (GPIO23)
/GPIO32: R12.1, U2.7 (32K_XP/GPIO32/ADC1_CH4)
/GPIO33: R11.1, U2.8 (32K_XN/GPIO33/ADC1_CH5)
/I2C_SCL: J6.2, R4.2, U2.36 (GPIO22)
/I2C_SDA: J6.4, R3.2, U2.33 (GPIO21)
/PWM1: J1.3, U2.12 (MTMS/GPIO14/ADC2_CH6)
/PWM2: J1.1, U2.11 (ADC2_CH7/GPIO27)
/PWM3: J2.3, U2.9 (DAC_1/ADC2_CH8/GPIO25)
/PWM4: J2.1, U2.10 (DAC_2/ADC2_CH9/GPIO26)
GND: C1.2, C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, D1.1 (K), J1.2, J2.2, J3.1, J6.1, J8.3, J9.3, J10.3, J11.3, U1.2 (VSS), U1.8 (STBY), U2.14 (GND), U2.32 (GND), U2.38 (GND)
unnamed: D1.2 (A), R1.2
unnamed: J4.1, R2.1
unnamed: C4.1, J8.1, R5.1, R9.2
unnamed: C5.1, J9.1, R6.1, R10.2
unnamed: C6.1, J10.1, R7.1, R11.2
unnamed: C7.1, J11.1, R8.1, R12.2

Notes on the sheet:
予備GPIO
シリアルサーボ
PWM 4ch
使わない方がいいピン ブートストラップピン： GPIO 0,2,5,12,15 内蔵FLASHで使用： GPIO 6,7,8,9,10 入力専用・プルアップ・ダウン不可： GPIO 34,35,36,39 外部PSRAMで使用(WROVERのみ)： GPIO 16,17
プルアップ プルダウン RCフィルタ に対応
CAN通信
I2C
5V電源LED

Board: 2 copper layers, 85.0 x 60.0 mm, 33 parts (0 on the bottom side), 24 nets.

File ESP32-DevKitC_control_board/docs/ESP32-DevKitC_control_board_bom.csv:

"Reference","Qty","Value","Footprint","説明","Buy_URL"
"C1,C3","2","0.1u","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P2.50mm","0.1μF50V X7R","https://akizukidenshi.com/catalog/g/g113582/"
"C2","1","47u","Capacitor_THT:CP_Radial_D6.3mm_P2.50mm","47μF63V","https://akizukidenshi.com/catalog/g/g117403/"
"C4-C7","4","R兼用","Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm","Unpolarized capacitor",""
"D1","1","LED","LED_THT:LED_D5.0mm","Light emitting diode",""
"J1,J2","2","Conn_01x03_Pin","OU_connector:S03B-PASK-2","S03B-PASK-2",""
"J3,J5,J7","3","Conn_01x02_Pin","OU_connector:DF1E-2P-2.5DS","DF1E-2P-2.5DS",""
"J4","1","Conn_01x02_Pin","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","Generic connector, single row, 01x02, script generated",""
"J6","1","Conn_01x04_Pin","OU_connector:DF1E-4P-2.5DS","Generic connector, single row, 01x04, script generated",""
"J8-J11","4","Conn_01x03_Pin","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","Generic connector, single row, 01x03, script generated",""
"R1","1","1k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","Resistor",""
"R2","1","120","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","Resistor","https://akizukidenshi.com/catalog/g/g125121/"
"R3,R4","2","4.7k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","Resistor","https://akizukidenshi.com/catalog/g/g125472/"
"R5-R8","4","","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","Resistor",""
"R9-R12","4","0","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","Resistor",""
"U1","1","MCP2562-E-P","Package_DIP:DIP-8_W7.62mm","High-Speed CAN Transceiver, 1Mbps, 5V supply, Vio pin, -40C to +125C, DIP-8","https://akizukidenshi.com/catalog/g/g114383/"
"U2","1","ESP32-DevKitC","PCM_Espressif:ESP32-DevKitC","Development Kit",""

## KiCad design serial_servo_control_board/serial_servo_control_board.kicad_pcb

File serial_servo_control_board/README.md:

# 【ver 】serial_servo_control_board

## 回路図 (Schematic)

---

## 外観 (3D Rendering)

| 表面 (Top) | 裏面 (Bottom) |
| :---: | :---: |
|  |  |

| 斜視 (Isometric) | 反対斜視 (Reverse Isometric) |
| :---: | :---: |
|  |  |

---

## 機能の紹介

---

## コネクタ・ピンアサイン

### J1: 

| ピン | 種類 | 信号名 | 説明 |
| --- | --- | --- | --- |
| | | | |

---

## 安全・禁止事項・注意事項

### 禁止事項

### 注意事項

---

## 更新履歴
| 対象基板バージョン | 日付 | 変更内容 |
| --- | --- | --- |
| | | |

---

## 関連成果物・リンク

- **回路図 (PDF)**: [`docs/serial_servo_control_board_schematic.pdf`](docs/serial_servo_control_board_schematic.pdf)
- **回路図 (SVG)**: [`docs/serial_servo_control_board_schematic.svg`](docs/serial_servo_control_board_schematic.svg)
- **部品表 (BOM)**: [`docs/serial_servo_control_board_bom.csv`](docs/serial_servo_control_board_bom.csv)
- **3D CADモデル (STEP)**: [`serial_servo_control_board.step`](serial_servo_control_board.step)
- **製造データ (Gerber)**: 発注用ガーバーZIPは [GitHub Releases](../../releases) を参照してください。

Parts:
C1: 0.33u; C_Disc_D3.8mm_W2.6mm_P2.50mm
C2: 470u; CP_Radial_D10.0mm_P5.00mm
C3: 2.2u; C_Disc_D6.0mm_W4.4mm_P5.00mm
C4, C5: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
D1, D2: 1N4148; D_DO-34_SOD68_P2.54mm_Vertical_CathodeUp
J1: Conn_01x04_Pin; DF1E-4P-2.5DS
J2: Conn_01x02_Pin; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J3: Conn_01x03_Pin; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
Q1, Q2: BSS138; SOT-23
R1, R3, R4: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
TP1, TP2: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP3, TP4: TestPoint_Probe; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: NJM2884U2-05; SOT-89-5
U2, U3: TLP2745; SO-6L_10x3.84mm_P1.27mm

Connections:
+5V_CTRL: C5.2, J1.3, R1.1, U3.6 (VDD)
+5V_PWR: C3.1, C4.2, R3.2, R4.1, U1.4 (VOUT), U2.6 (VDD)
+SERVO: C1.2, C2.1, J2.2, J3.2, U1.1 (CTRL), U1.5 (VIN)
/RX: J1.4, TP3.1 (1_1), U3.5 (VO)
/TX: J1.2, U2.3 (K)
/signal: J3.3, Q1.1 (G), Q2.3 (D), R4.2, TP4.1 (1_1)
GND: C5.1, J1.1, TP1.1 (1_1), U3.4 (GND)
GNDPWR: C1.1, C2.2, C3.2, C4.1, J2.1, J3.1, Q1.2 (S), Q2.2 (S), R2.1, TP2.1 (1_1), U1.2 (GND), U2.4 (GND)
unnamed: D1.2 (A), R1.2
unnamed: D1.1 (K), D2.2 (A)
unnamed: D2.1 (K), U2.1 (A)
unnamed: Q1.3 (D), U3.3 (K)
unnamed: Q2.1 (G), R2.2, U2.5 (VO)
unnamed: R3.1, U3.1 (A)

Notes on the sheet:
6.0V

Board: 2 copper layers, 35.0 x 50.0 mm, 23 parts (1 on the bottom side), 14 nets.

## KiCad design Nucleo-F446RE_control_board/Nucleo-F446RE_control_board.kicad_pcb

File Nucleo-F446RE_control_board/README.md:

# 【ver 】Nucleo-F446RE_control_board

## 回路図 (Schematic)

---

## 外観 (3D Rendering)

| 表面 (Top) | 裏面 (Bottom) |
| :---: | :---: |
|  |  |

| 斜視 (Isometric) | 反対斜視 (Reverse Isometric) |
| :---: | :---: |
|  |  |

---

## 機能の紹介

---

## コネクタ・ピンアサイン

### J1: 

| ピン | 種類 | 信号名 | 説明 |
| --- | --- | --- | --- |
| | | | |

---

## 安全・禁止事項・注意事項

### 禁止事項

### 注意事項

---

## 更新履歴
| 対象基板バージョン | 日付 | 変更内容 |
| --- | --- | --- |
| | | |

---

## 関連成果物・リンク

- **回路図 (PDF)**: [`docs/Nucleo-F446RE_control_board_schematic.pdf`](docs/Nucleo-F446RE_control_board_schematic.pdf)
- **回路図 (SVG)**: [`docs/Nucleo-F446RE_control_board_schematic.svg`](docs/Nucleo-F446RE_control_board_schematic.svg)
- **部品表 (BOM)**: [`docs/Nucleo-F446RE_control_board_bom.csv`](docs/Nucleo-F446RE_control_board_bom.csv)
- **3D CADモデル (STEP)**: [`Nucleo-F446RE_control_board.step`](Nucleo-F446RE_control_board.step)
- **製造データ (Gerber)**: 発注用ガーバーZIPは [GitHub Releases](../../releases) を参照してください。

Parts:
C1: 47u; CP_Radial_D6.3mm_P2.50mm
C2, C8, C9, C10: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C3, C4, C5, C6, C7: R兼用; C_Disc_D3.8mm_W2.6mm_P2.50mm; not fitted
D1: LED; LED_D5.0mm
J1, J8, J16: Conn_01x02_Pin; DF1E-2P-2.5DS
J2, J3, J4, J5, J6: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical; not fitted
J7, J15: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J9, J13, J14: Conn_01x04_Pin; DF1E-4P-2.5DS
J10, J11, J12: Conn_01x03_Pin; S03B-PASK-2
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2, R3, R4, R5, R6: R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
R7, R8, R9, R10, R11: 0; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
R12, R15: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R13, R14: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
U1: F446RE_mainPIN
U2, U3: MCP2562-E-P; DIP-8_W7.62mm

Connections:
+3.3V: C8.2, C10.2, J2.2, J3.2, J4.2, J5.2, J6.2, J9.3, J13.3, R2.2, R3.2, R4.2, R5.2, R6.2, R13.1, R14.1, U1.CN7_16 (CN7_+3V3), U2.5 (Vio), U3.5 (Vio)
+5V: C1.1, C2.1, C9.1, J1.2, J14.3, R1.1, U1.CN7_6 (E5V), U2.3 (VDD), U3.3 (VDD)
/CAN1+: J7.2, J8.1, U2.7 (CANH)
/CAN1-: J8.2, R12.2, U2.6 (CANL)
/CAN1_RX: U1.CN10_14 (PA11), U2.4 (RXD)
/CAN1_TX: U1.CN10_12 (PA12), U2.1 (TXD)
/CAN2+: J15.2, J16.1, U3.7 (CANH)
/CAN2-: J16.2, R15.2, U3.6 (CANL)
/CAN2_RX: U1.CN10_16 (PB12), U3.4 (RXD)
/CAN2_TX: U1.CN10_30 (PB13), U3.1 (TXD)
/I2C_SCL: J9.2, R14.2, U1.CN10_3 (PB8)
/I2C_SDA: J9.4, R13.2, U1.CN10_5 (PB9)
/PA4: R7.1, U1.CN7_32 (PA4)
/PA9: J14.2, U1.CN10_21 (PA9)
/PA10: J14.4, U1.CN10_33 (PA10)
/PB0: R8.1, U1.CN7_34 (PB0)
/PB14: J13.2, U1.CN10_28 (PB14)
/PB15: J13.4, U1.CN10_26 (PB15)
/PC2: R9.1, U1.CN7_35 (PC2)
/PC3: R10.1, U1.CN7_37 (PC3)
/PC10: R11.1, U1.CN7_1 (PC10)
/PWM1: J10.3, U1.CN10_4 (PC6)
/PWM2: J10.1, U1.CN10_19 (PC7)
/PWM3: J11.3, U1.CN10_2 (PC8)
/PWM4: J11.1, U1.CN10_1 (PC9)
/PWM5: J12.3, U1.CN7_28 (PA0)
/PWM6: J12.1, U1.CN7_30 (PA1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.2, C10.1, D1.1 (K), J1.1, J2.3, J3.3, J4.3, J5.3, J6.3, J9.1, J10.2, J11.2, J12.2, J13.1, J14.1, U1.CN7_8 (CN7_GND), U1.CN7_19 (CN7_GND__1), U1.CN7_20 (CN7_GND__2), U1.CN7_22 (CN7_GND__3), U1.CN10_9 (CN10_GND), U1.CN10_20 (CN10_GND__1), U2.2 (VSS), U2.8 (STBY), U3.2 (VSS), U3.8 (STBY)
unnamed: D1.2 (A), R1.2
unnamed: C3.1, J2.1, R2.1, R7.2
unnamed: C4.1, J3.1, R3.1, R8.2
unnamed: C5.1, J4.1, R4.1, R9.2
unnamed: C6.1, J5.1, R5.1, R10.2
unnamed: C7.1, J6.1, R6.1, R11.2
unnamed: J7.1, R12.1
unnamed: J15.1, R15.1

Notes on the sheet:
プルアップ プルダウン RCフィルタ に対応
5V電源LED
I2C
PWM
シリアルサーボ
CAN通信
空圧用
予備GPIO

Board: 2 copper layers, 100.0 x 90.0 mm, 45 parts (0 on the bottom side), 36 nets.

File Nucleo-F446RE_control_board/docs/Nucleo-F446RE_control_board_bom.csv:

"Reference","Qty","Value","Footprint","説明","Buy_URL"
"C1","1","47u","Capacitor_THT:CP_Radial_D6.3mm_P2.50mm","47μF63V","https://akizukidenshi.com/catalog/g/g117403/"
"C2,C8-C10","4","0.1u","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P2.50mm","0.1μF50V X7R","https://akizukidenshi.com/catalog/g/g113582/"
"C3-C7","5","R兼用","Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm","Unpolarized capacitor",""
"D1","1","LED","LED_THT:LED_D5.0mm","Light emitting diode",""
"J1,J8,J16","3","Conn_01x02_Pin","OU_connector:DF1E-2P-2.5DS","DF1E-2P-2.5DS",""
"J2-J6","5","Conn_01x03_Pin","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","Generic connector, single row, 01x03, script generated",""
"J7,J15","2","Conn_01x02_Pin","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","Generic connector, single row, 01x02, script generated",""
"J9,J13,J14","3","Conn_01x04_Pin","OU_connector:DF1E-4P-2.5DS","DF1E-4P-2.5DS",""
"J10-J12","3","Conn_01x03_Pin","OU_connector:S03B-PASK-2","S03B-PASK-2",""
"R1","1","1k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","Resistor",""
"R2-R6","5","","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","Resistor",""
"R7-R11","5","0","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","Resistor",""
"R12,R15","2","120","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","Resistor","https://akizukidenshi.com/catalog/g/g125121/"
"R13,R14","2","4.7k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","Resistor","https://akizukidenshi.com/catalog/g/g125472/"
"U1","1","","OU_Micon:F446RE_mainPIN","",""
"U2,U3","2","MCP2562-E-P","Package_DIP:DIP-8_W7.62mm","High-Speed CAN Transceiver, 1Mbps, 5V supply, Vio pin, -40C to +125C, DIP-8","https://akizukidenshi.com/catalog/g/g114383/"

## KiCad design servo_control_board/servo_control_board.kicad_pcb

Parts:
C1, C2, C3, C4: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C5: 470u; CP_Radial_D10.0mm_P5.00mm
J1, J2: Conn_01x03_Pin; S03B-PASK-2
J3, J4, J5, J6: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Horizontal
J7: Conn_01x02_Pin; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
R1, R2, R3, R4: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R5, R6, R7, R8: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
TP1, TP2, TP4, TP5, TP6, TP7, TP8, TP9: TestPoint_Probe; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP3, TP10: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1, U2, U3, U4: H11L1M; DIP-6_W7.62mm_LongPads

Connections:
+SERVO: C1.2, C2.2, C3.2, C4.2, C5.1, J3.2, J4.2, J5.2, J6.2, J7.2, R5.1, R6.1, R7.1, R8.1, U1.6 (VCC), U2.6 (VCC), U3.6 (VCC), U4.6 (VCC)
GND: J1.2, J2.2, TP3.1 (1_1), U1.2, U2.2, U3.2, U4.2
GNDPWR: C1.1, C2.1, C3.1, C4.1, C5.2, J3.1, J4.1, J5.1, J6.1, J7.1, TP10.1 (1_1), U1.5 (GND), U2.5 (GND), U3.5 (GND), U4.5 (GND)
unnamed: J1.1, R1.1, TP1.1 (1_1)
unnamed: J1.3, R3.1, TP4.1 (1_1)
unnamed: J2.1, R2.1, TP2.1 (1_1)
unnamed: J2.3, R4.1, TP5.1 (1_1)
unnamed: J3.3, R5.2, TP6.1 (1_1), U1.4
unnamed: J4.3, R6.2, TP7.1 (1_1), U2.4
unnamed: J5.3, R7.2, TP8.1 (1_1), U3.4
unnamed: J6.3, R8.2, TP9.1 (1_1), U4.4
unnamed: R1.2, U2.1
unnamed: R2.2, U4.1
unnamed: R3.2, U1.1
unnamed: R4.2, U3.1
